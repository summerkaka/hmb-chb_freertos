# IAR project app.ewp, settings and files
configuration app (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373RC ST STM32F373RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F373xC
  ICCARM.CCIncludePath2: ../Bsp; ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc; ..\\bsp
  OBJCOPY.OOCOutputFile: app.hex
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: stm32f373xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/app
    ../App/: AD5241.c Adaptor.c adc_app.c Battery.c can_app.c eeprom.c FieldCase.c freertos.c load.c LTC2943.c main.c sdadc_app.c SysTick.c uart_printf.c
  group Application/bsp
    ../Bsp/: adc.c adc.h can.c can.h dma.c dma.h gpio.c gpio.h i2c.c i2c.h iwdg.c iwdg.h main.h sdadc.c sdadc.h stm32f3xx_hal_conf.h stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_tim.c stm32f3xx_it.c stm32f3xx_it.h tim.c tim.h usart.c usart.h
  group Application/EWARM
    ./: startup_stm32f373xc.s
  group Application/inc
    ../Inc/: AD5241.h Adaptor.h adc_app.h app.h Battery.h can_app.h eeprom.h FieldCase.h FreeRTOSConfig.h load.h LTC2943.h sdadc_app.h SysTick.h
  group Drivers/CMSIS
    ../Bsp/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
