<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\hmb-chb_freertos-master\EWARM\app.ewp</path>
    </project>
    <batchBuild />
</workspace>
